BB_GIT_SHALLOW = "1"
BB_GIT_SHALLOW_DEPTH = "1"

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://ikconfig.cfg"
